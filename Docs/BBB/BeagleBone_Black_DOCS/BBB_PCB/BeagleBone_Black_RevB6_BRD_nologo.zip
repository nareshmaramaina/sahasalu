# Allegro board BeagleBone_Black_RevB6_nologo.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PROC_A15: length 15.2
  TOP w0.121: U5.A15 v1(40.92,22.01) 40.37,21.46 39.62,21.46 38.34,20.18 38.34,16.4 38.86,15.88 38.86,12.95 v1(39.88,11.94)
  BOTTOM w0.121: v1(39.88,11.94) 40.39,12.45 41.4,12.45 R18.1
PWR_BUT: length 59.8
  TOP w0.121: S3.4 S3.2 10.83,41.11 11.56,40.39 v1(14.1,40.39) ; v1(26.92,12.06) 26.42,12.06 25.93,12.55 U2.25
  LYR4 w0.133: v1(14.1,40.39) 13.84,40.13 13.84,35.94 13.34,35.43 13.34,24.26 15.11,22.48 19.05,22.48 21.21,20.32 24.13,20.32 25.65,18.8 25.65,13.34 v1(26.92,12.06) 28.57,10.41 28.57,3.17 P9.9
PWR_LEDR: length 2.3
  TOP w0.121: D1.1 2.98,17.21 v1(3.05,17.27)
  BOTTOM w0.121: R12.2 3.3,17.02 v1(3.05,17.27)
RBIAS: length 2.7
  TOP w0.121: v1(21.27,28.26) 21.91,28.89 21.91,29.21 22.06,29.36 U14.32
  BOTTOM w0.121: v1(21.27,28.26) R144.1
RCLKIN: length 8
  TOP w0.121: U14.5 25.33,27.94 25.34,27.94 v1(25.34,27.69) 25.75,27.27 27.98,27.27 v1(29.21,26.04)
  BOTTOM w0.121: R142.2 26.04,26.99 v1(25.34,27.69) ; R140.2 v1(29.21,26.04)
REFCLKO: length 6.2
  TOP w0.121: R118.1 R124.2 v1(29.21,26.99) 28.77,26.99 28.13,27.62 26.92,27.62 26.33,28.21 U14.7
  BOTTOM w0.121: R124.2 v1(29.21,26.99)
RXD0/MODE0: length 4.1
  TOP w0.121: U14.11 28.59,30.36 29.02,30.8 v1(29.21,30.8) 29.21,30.48 29.34,30.35 29.84,30.35 29.97,30.48 R128.2
  BOTTOM w0.121: R128.2 v1(29.21,30.8)
RXD1/MODE1: length 4
  TOP w0.121: U14.10 28.89,29.86 29.19,29.86 v1(29.21,29.84) 29.21,29.5 29.34,29.37 29.88,29.37 29.97,29.46 R127.2
  BOTTOM w0.121: R127.2 v1(29.21,29.84)
RXD2/RMIISEL: length 4.1
  TOP w0.121: U14.9 28.74,29.36 v1(29.21,28.89) 29.21,28.57 29.34,28.45 29.84,28.45 29.97,28.57 R126.2
  BOTTOM w0.121: R126.2 v1(29.21,28.89)
RXD3/PHYAD2: length 4.3
  TOP w0.121: R125.2 v1(29.21,27.94) 28.81,28.34 26.96,28.34 26.83,28.47 U14.8
  BOTTOM w0.121: R125.2 v1(29.21,27.94)
RXDV: length 2.8
  TOP w0.121: v1(21.27,33.66) 21.72,33.21 21.72,32.83 22.18,32.37 U14.26
  BOTTOM w0.121: R129.2 v1(21.27,33.66)
RXER/PHYAD0: length 4.1
  TOP w0.121: R133.2 29.97,31.37 29.88,31.27 29.34,31.27 29.21,31.4 v1(29.21,31.75) 28.83,31.37 U14.13
  BOTTOM w0.121: R133.2 v1(29.21,31.75)
RXN: length 18.4
  TOP w0.095: U14.30 22.03,30.36 21.9,30.23 21.34,30.23 v1(21.27,30.16) 20.94,29.83 20.66,29.83 20.09,30.39 20.09,31.99 19.29,32.79 18.43,32.79 17.64,32 16.64,32 16,32.64 16,33.92 16.26,34.17 16.89,34.17 17.14,33.92 P5.2
  BOTTOM w0.095: R121.1 v1(21.27,30.16)
  BOTTOM w0.121: C138.1 P5.2
RXP: length 15.9
  TOP w0.095: U14.31 22.02,29.86 21.93,29.95 21.68,29.95 21.53,29.79 21.53,29.46 v1(21.27,29.21) 20.94,29.55 20.54,29.55 19.81,30.28 19.81,31.88 19.18,32.51 18.54,32.51 17.75,31.72 16.52,31.72 15.72,32.52 15.72,34.04 15.47,34.29 P5.1
  BOTTOM w0.095: R120.1 v1(21.27,29.21)
  BOTTOM w0.121: C137.1 P5.1
SPI1_CS0: length 76.1
  TOP w0.121: v1(64.26,34.8) 63.75,35.31 U11.25 ; v1(43.32,23.61) U5.C12
  LYR4 w0.133: v1(43.32,23.61) 43.32,22.72 44.32,21.72 44.32,19.94 44.07,19.68 44.07,15.49 44.58,14.99 46.48,14.99 51.56,9.91 51.56,5.59 P9.28 ; v1(57.02,12.45) 57.66,11.8 58.92,11.8 61.59,14.48 66.1,14.48 69.28,17.65 70.36,17.65 71.12,18.41 71.12,33.02 69.85,34.29 64.77,34.29 v1(64.26,34.8)
  BOTTOM w0.121: P9.28 53.59,5.33 54.61,5.33 57.53,8.25 57.53,11.94 v1(57.02,12.45)
SPI1_D0: length 81.5
  TOP w0.121: v1(63.63,34.8) 63.25,35.17 U11.24 ; U5.B13 v1(42.52,22.81)
  LYR4 w0.133: 55.24,1.91 54.1,3.05 52.07,3.05 51.82,3.3 49.78,3.3 49.02,4.06 49.02,11.5 46.02,14.5 44.04,14.5 43.56,14.99 43.56,20.19 42.11,21.64 42.11,22.4 v1(42.52,22.81) ; v1(63.63,34.8) 64.39,34.04 69.72,34.04 70.87,32.89 70.87,18.67 70.23,18.03 69.15,18.03 65.85,14.73 61.47,14.73 58.78,12.04 58.19,12.04 v1(57.78,12.45)
  BOTTOM w0.121: v1(57.78,12.45) 57.78,8 56.26,6.48 56.26,2.92 55.24,1.91
SPI1_D1: length 26.9
  TOP w0.121: v1(43.32,24.41) U5.D12
  LYR4 w0.121: v1(43.32,24.41) 43.72,24.01 43.72,23.11
  LYR4 w0.133: 55.24,4.45 55.24,5.97 53.98,7.24 53.98,8 46.74,15.24 44.83,15.24 44.32,15.75 44.32,19.42 44.7,19.81 44.7,22.13 43.72,23.11
SPI1_SCLK: length 81.1
  TOP w0.121: U11.23 62.75,35.04 v1(62.99,34.8) ; U5.A13 v1(42.52,22.01)
  LYR4 w0.133: P9.31 56.39,3.3 52.32,3.3 51.31,4.32 51.31,9.65 46.22,14.74 44.32,14.74 43.81,15.24 43.81,19.94 44.07,20.19 44.07,21.21 43.27,22.01 v1(42.52,22.01) ; v1(62.99,34.8) 64.01,33.78 69.6,33.78 70.61,32.77 70.61,18.92 70.1,18.41 69.02,18.41 65.6,14.99 61.09,14.99 v1(58.55,12.45)
  BOTTOM w0.121: P9.31 56.52,3.17 56.52,6.22 58.04,7.75 58.04,11.94 v1(58.55,12.45)
SYS_5V: length 113.1
  TOP w0.203: U2.39 v1(24.26,19.11) ; U2.32 26.57,15.84 26.92,16.19 v1(26.92,16.45) ; U2.2 19.15,17.04 v1(18.8,17.4) ; U2.42 23.06,19 v1(22.99,19.11) ; U2.7 19.04,15.04 v1(18.8,14.8) 18.95,14.64 U2.8 ; U2.22 24.26,11.31 v1(24.13,11.18) 23.86,11.45 U2.21
  TOP w0.381: R72.1 v1(7.62,47.31) ; v1(7.62,45.33) 7.54,45.4 R74.1 ; v1(7.62,46.39) 7.59,46.35 R73.1 ; R71.1 v1(7.62,44.45)
  TOP w0.762: RT1.1 67.88,8.19 C34.1
  LYR3 w0.381: v1(9.53,15.88) 10.54,16.89 18.29,16.89 v1(18.8,17.4)
  LYR3 w0.762: v1(18.8,17.4) 24.26,17.4 ; 24.26,17.4 25.97,17.4 v1(26.92,16.45) 26.92,15.56 24.13,12.76 v1(24.13,11.18) ; 24.26,17.4 v1(24.26,19.11)
  LYR4 w0.381: v1(7.62,47.31) v1(7.62,46.39) v1(7.62,45.33) v1(7.62,44.45) 12.95,39.12 12.95,36.58 12.45,36.07 12.45,23.62 12.95,23.11 12.95,19.3 v1(9.53,15.88) ; v1(18.8,17.4) 19.43,16.76 19.43,15.37 18.86,14.8 v1(18.8,14.8)
  LYR4 w0.762: P9.8 27.3,5.97 23.75,9.53 23.75,10.79 v1(24.13,11.18)
  LYR5_PWR w0.889: RT1.1 68.72,9.03 ; RT1.1 68.72,7.48 ; RT1.1 67.17,7.48 ; RT1.1 67.17,9.03 ; 28.04,3.71 P9.8 26.57,3.71 ; 26.57,2.64 P9.7 28.04,2.64
  BOTTOM w0.381: v1(24.13,11.18) 23.81,11.49 C7.2 C8.2 ; v1(22.99,19.11) 23.24,19.11 23.5,18.86 23.5,18.35 C13.2 24.26,18.48 v1(24.26,19.11) ; U8.2 75.86,14.28 v1(75.54,14.61) 75.86,14.93 U8.3 ; v1(18.8,14.8) 18.8,14.54 19.11,14.22 C10.2 ; C17.1 v1(9.53,15.88) U4.2
  BOTTOM w0.762: P9.7 P9.8
SYS_RESETN: length 94.6
  TOP w0.121: P9.10 31.1,5.7 U16.4 ; S1.4 S1.2 v1(9.99,49.4) ; U5.A10 45.32,22.08 44.7,21.46 44.7,20.83 43.81,19.94 42.8,19.94 41.66,18.8 41.66,16.76 41.91,16.51 v1(42.42,16.51) ; U14.19 v1(25.83,34.61)
  LYR3 w0.133: v1(42.42,16.51) 41.91,16 38.35,16 38.1,15.75 34.73,15.75 v1(34.29,16.19)
  LYR4 w0.133: v1(9.99,49.4) 11.04,49.4 v1(25.83,34.61) 28.39,34.61 29.72,33.27 29.72,23.88 28.83,22.99 28.83,19.94 v1(29.97,18.8) 30.48,18.29 30.48,15.75 27.62,12.89 v1(27.62,12.06) 28.96,10.73 28.96,5.33 P9.10
  BOTTOM w0.121: v1(34.29,16.19) P2.15 30.8,16.19 30.48,16.51 30.48,18.29 v1(29.97,18.8) ; v1(27.62,12.06) R14.2 C24.1 C30.1
TCT_RCT: length 6.4
  BOTTOM w0.121: P5.4 15.88,29.21 P5.5 R137.1 C141.1
TESTOUT: length 2.9
  TOP w0.121: U5.A3 51.44,21.89 TP3.1
TIMER4: length 31.3
  TOP w0.121: v1(48.12,34.01) U5.R7
  LYR3 w0.121: 47.72,35.05 47.72,34.41 v1(48.12,34.01)
  LYR3 w0.133: v1(34.04,48.26) 37.85,44.45 41.4,44.45 46.75,39.1 46.75,36.31 47.72,35.34 47.72,35.05
  LYR4 w0.133: P8.7 27.3,49.15 28.7,47.75 33.53,47.75 v1(34.04,48.26)
TIMER5: length 28.1
  TOP w0.121: v1(48.92,34.81) U5.T6
  LYR3 w0.133: v1(35.81,48.26) 36.32,47.75 39.62,47.75 48.39,38.99 48.39,35.69 48.92,35.15 v1(48.92,34.81)
  LYR4 w0.133: P8.9 30.86,49.15 34.92,49.15 v1(35.81,48.26)
TIMER6: length 37
  TOP w0.121: v1(50.16,48.26) 49.66,47.75 49.66,44.96 49.02,44.32 49.02,38.73 49.4,38.35 49.4,37.72 48.92,37.24 48.92,35.61 U5.U6
  LYR4 w0.133: P8.10 30.99,51.56 48.13,51.56 48.9,50.8 48.9,49.53 v1(50.16,48.26)
TIMER7: length 31.8
  TOP w0.121: v1(48.12,34.81) U5.T7
  LYR3 w0.133: v1(48.12,34.81) 48.12,38.24 41.53,44.83 38.99,44.83 37.59,46.23 36.96,46.23 v1(34.92,48.26)
  LYR4 w0.133: P8.8 28.57,51.44 28.57,49.78 29.59,48.77 34.42,48.77 v1(34.92,48.26)
TXCLK: length 6
  TOP w0.121: v1(29.21,35.56) 28.66,35.01 25.67,35.01 25.33,34.67 U14.20
  BOTTOM w0.121: R134.2 v1(29.21,35.56)
TXN: length 20.3
  TOP w0.095: U14.28 21.59,31.37 21.27,31.69 v1(21.27,32.07)
  LYR3 w0.102: P5.6 17.14,29.09 16.89,29.34 16.15,29.34 15.9,29.09 15.9,27.66 16.71,26.85 18.21,26.85 19.81,28.45 19.81,30.09 20.88,31.16 20.88,31.68 v1(21.27,32.07)
  BOTTOM w0.095: R123.1 v1(21.27,32.07)
  BOTTOM w0.121: P5.6 C140.1
TXP: length 17.8
  TOP w0.095: U14.29 22.03,30.86 21.81,31.09 21.28,31.09 21.27,31.1 v1(21.27,31.11)
  LYR3 w0.102: P5.3 15.6,30.76 15.6,27.53 16.59,26.54 18.34,26.54 20.12,28.32 20.12,29.96 v1(21.27,31.11)
  BOTTOM w0.095: R122.1 v1(21.27,31.11)
  BOTTOM w0.121: C139.1 P5.3
U5_H18: length 4.2
  TOP w0.121: R28.1 37.9,27.81 38.1,28.01 U5.H18
U5_R13: length 10.5
  TOP w0.121: v1(42.52,34.01) U5.R13
  LYR3 w0.121: v1(42.52,34.01) 42.92,34.41 42.92,35.06 42.55,35.43
  LYR3 w0.133: v1(38.42,40.64) 38.42,38.67 39.75,37.34 40.64,37.34 42.55,35.43
  BOTTOM w0.121: v1(38.42,40.64) R160.1
U5_T13: length 9.8
  TOP w0.121: v1(42.52,34.81) U5.T13
  LYR3 w0.133: v1(37.15,40.64) 37.15,39.43 39.62,36.96 40.39,36.96 42.52,34.82 v1(42.52,34.81)
  BOTTOM w0.121: v1(37.15,40.64) R161.1
UART0_RX: length 35.3
  TOP w0.121: v1(40.92,25.21) U5.E15
  LYR4 w0.121: 39.75,25.53 39.83,25.61 40.52,25.61 v1(40.92,25.21)
  LYR4 w0.133: v1(39.88,10.16) 40.41,10.69 40.41,19.02 39.19,20.24 39.19,24.97 39.75,25.53
  BOTTOM w0.121: U15.6 53.22,11.68 52.32,12.57 50.16,12.57 49.53,11.94 49.53,10.41 48.51,9.4 44.45,9.4 44.2,9.65 40.39,9.65 39.88,10.16 v1(39.88,10.16)
UART0_TX: length 32.2
  TOP w0.121: v1(40.12,25.21) U5.E16
  LYR4 w0.133: v1(41.15,10.16) 40.65,10.66 40.65,20.19 39.45,21.38 39.45,24.54 v1(40.12,25.21)
  BOTTOM w0.121: U15.5 53.23,12.18 52.58,12.83 49.91,12.83 49.28,12.19 49.28,10.67 48.26,9.65 44.7,9.65 44.45,9.91 41.4,9.91 v1(41.15,10.16)
UART1_RXD: length 25.6
  TOP w0.121: v1(40.12,24.41) U5.D16
  LYR4 w0.121: v1(40.12,24.41) 40.52,24.01 40.52,21.72
  LYR4 w0.133: 40.52,21.72 40.52,21.58 41.66,20.45 41.66,13.59 44.45,10.79 44.45,9.53 v1(45.09,8.89)
  BOTTOM w0.121: P9.26 48.77,5.84 47.75,5.84 46.35,7.24 46.35,8.13 45.59,8.89 v1(45.09,8.89)
UART1_TXD: length 23.5
  TOP w0.121: v1(40.92,24.41) U5.D15
  LYR4 w0.121: v1(40.92,24.41) 41.32,24.01 41.32,23.37
  LYR4 w0.133: P9.24 46.35,5.71 46.35,9.78 44.45,11.68 44.07,11.68 41.91,13.84 41.91,20.7 41.33,21.28 41.33,23.35 41.32,23.37
UART2_RXD: length 22.7
  TOP w0.121: U5.A17 39.72,22.18 39.72,22.17 39.72,21.94 38.09,20.31 38.09,16.26 38.61,15.75 38.61,9.02 41.66,5.97 43.56,5.97 P9.22
UART2_TXD: length 26
  TOP w0.121: P9.21 43.81,3.17 43.81,4.83 43.05,5.59 41.53,5.59 38.35,8.76 38.35,15.62 37.85,16.13 37.85,20.45 39.32,21.92 39.32,22.81 U5.B17
UART4_RXD: length 40.9
  TOP w0.121: v1(36.07,36) 36.64,35.43 36.96,35.43 37.58,34.81 39.32,34.81 U5.T17
  LYR4 w0.133: v1(33.15,6.48) 33.15,16.38 34.29,17.53 34.29,23.11 34.54,23.37 34.54,35.31 35.37,36.13 35.94,36.13 v1(36.07,36)
  BOTTOM w0.121: P9.11 33.66,3.17 33.66,5.4 33.15,5.91 v1(33.15,6.48)
UART4_TXD: length 44.5
  TOP w0.121: v1(36.83,37.59) 37.34,37.08 37.34,35.94 37.67,35.61 39.08,35.61 39.48,35.21 U5.U17 ; v1(32.26,6.48) 33.66,5.08 33.66,3.17 P9.13
  LYR4 w0.133: v1(32.26,6.48) 32.26,16.51 33.78,18.03 33.78,23.37 34.04,23.62 34.04,36.32 35.71,38 36.42,38 v1(36.83,37.59)
USB0_DM: length 40.1
  TOP w0.114: v1(11.94,41.91) U10.2 12.92,41.91 13.02,42.01 13.02,42.69 13.13,42.8 14.48,42.8 20.47,36.8 30.36,36.8 30.75,36.42 33.43,36.42 35.2,34.65 35.69,34.65 36.07,34.26 36.07,32.88 36.82,32.13 38.8,32.13 U5.N18
  BOTTOM w0.114: v1(11.94,41.91) 11.94,41.88 11.84,41.78 11.64,41.78 11.54,41.88 11.54,42.55 11.44,42.65 8.79,42.65 7.9,43.54 7.24,43.54 7.04,43.33 P4.2
USB0_DP: length 40.2
  TOP w0.114: U5.N17 39.32,32.41 36.94,32.41 36.35,32.99 36.35,34.41 35.83,34.92 35.32,34.92 33.54,36.7 30.86,36.7 30.48,37.08 20.59,37.08 14.59,43.08 12.98,43.08 12.57,42.67 12.57,42.42 U10.1 12.07,42.41 v1(11.94,42.55)
  BOTTOM w0.114: P4.3 6.92,44.13 7.24,43.81 8.02,43.81 8.9,42.93 11.56,42.93 11.82,42.66 11.82,42.66 v1(11.94,42.55)
USB0_ID: length 47.1
  TOP w0.121: v1(15.11,41.4) 14.61,40.89 12.71,40.89 12.58,41.02 U10.3 ; U5.P16 v1(40.12,33.21)
  BOTTOM w0.121: P4.4 7.03,44.93 7.11,44.85 7.98,44.85 8.76,44.07 13.21,44.07 15.11,42.16 v1(15.11,41.4) 17.04,39.48 40.15,39.48 40.45,39.18 40.45,35.12 40.52,35.05 40.52,33.61 v1(40.12,33.21)
USB1_DM: length 69.1
  TOP w0.114: v1(38.1,33.15) 38.1,33.4 38.43,33.73 38.8,33.73 U5.R18
  LYR3 w0.127: v1(78.08,17.14) 77.9,17.32 76.68,17.32 76.06,16.7 74.21,16.7 P3.2 70.11,15.83 68.07,13.79 47.5,13.79 46.61,14.68 40.77,14.68 39.29,13.21 v1(36.07,13.21)
  LYR4 w0.127: v1(36.07,13.21) 36.47,13.61 36.47,13.81 37.72,15.06 37.72,20.77 37.54,20.95 37.54,32.58 v1(38.1,33.15)
  BOTTOM w0.114: v1(78.08,17.14) 77.68,17.54 77.68,17.94 77.93,18.19 78.33,18.19 78.55,18.41 U9.2
USB1_DP: length 69.1
  TOP w0.114: v1(37.47,33.15) 38.32,34.01 39.32,34.01 U5.R17
  LYR3 w0.127: v1(36.07,13.84) 36.4,13.51 39.17,13.51 40.64,14.99 46.74,14.99 47.62,14.1 67.94,14.1 69.99,16.14 71.77,16.14 73.34,17.72 P3.3 74.17,17.01 75.93,17.01 76.56,17.63 77.92,17.63 v1(78.08,17.78)
  LYR4 w0.127: v1(37.47,33.15) 37.47,33 37.23,32.77 37.23,20.83 37.41,20.65 37.41,15.19 v1(36.07,13.84)
  BOTTOM w0.114: v1(78.08,17.78) 78.21,17.92 U9.1
USB1_DRVVBUS: length 52.5
  TOP w0.121: U5.F15 v1(40.92,26.01)
  LYR3 w0.133: v1(75.56,15.58) 75.14,15.58 74.3,14.73 69.85,14.73 68.58,13.46 43.05,13.46 v1(42.42,14.1)
  LYR4 w0.121: v1(40.92,26.01) 41.32,25.61 41.32,25.04 41.55,24.81 42.12,24.81 v1(42.52,24.41)
  BOTTOM w0.121: v1(42.42,14.1) 41.91,14.61 41.91,17.27 42.99,18.35 42.99,23.11 42.92,23.18 42.92,24.01 v1(42.52,24.41) ; v1(75.56,15.58) U8.4 77.04,16.92 76.81,17.14 R53.1
USB1_ID: length 1.9
  TOP w0.121: U5.P17 39.37,33.16 v1(39.32,33.21)
  BOTTOM w0.121: R49.2 39.05,33.97 39.32,33.71 v1(39.32,33.21)
USB1_OCN: length 72.8
  TOP w0.121: v1(40.12,34.81) U5.T16
  LYR3 w0.133: v1(83.16,17.14) 82.01,16 78.49,16 77.6,15.11 75.06,15.11 74.42,14.48 70.1,14.48 68.83,13.21 v1(39.88,13.21)
  LYR4 w0.133: v1(40.12,34.81) 39.76,34.81 38.73,33.78 38.73,32.89 38.1,32.26 38.1,25.76 37.77,25.43 37.77,21.41 38.1,21.08 38.1,14.99 v1(39.88,13.21)
  BOTTOM w0.121: U8.5 82.86,15.58 83.16,15.88 v1(83.16,17.14) R52.2
USB1_PWR: length 32.8
  TOP w0.635: v1(81.89,17.14) 83.15,15.88 v1(83.15,14.93)
  BOTTOM w0.305: U9.6 81.88,17.92 C35.1
  BOTTOM w0.381: C35.1 v1(81.89,17.14) ; 83.15,13.63 U8.8 ; U8.6 v1(83.15,14.93) ; 83.15,14.28 U8.7
  BOTTOM w0.508: FB8.2 FB7.1 67,10.09 67.31,9.78 72.01,9.78 74.42,12.19 82.4,12.19 83.15,12.95 v1(83.15,14.93)
USB1_VBUS: length 65.9
  TOP w0.305: v1(36.83,34.8) 36.84,34.8 37.23,34.41 U5.T18
  LYR3 w0.203: v1(31.75,37.15) 31.75,36.83 32,36.58 33.53,36.58 35.31,34.8 v1(36.83,34.8) ; v1(62.23,12.45) 61.79,12.89 56.32,12.89 55.5,12.06 44.2,12.06 43.69,12.57 35.69,12.57 32.89,15.37 32.89,17.4 30.73,19.56 v1(29.97,19.56)
  LYR4 w0.203: v1(29.97,19.56) 29.97,23.37 30.23,23.62 30.23,35.62 v1(31.75,37.15)
  BOTTOM w0.203: FB8.1 63.06,12.25 62.87,12.45 v1(62.23,12.45)
USB_DC: length 58.6
  TOP w0.121: U10.6 14.09,42.41 v1(14.1,42.4) ; U2.12 19.79,12.54 19.56,12.32 v1(18.8,12.32) ; v1(12.7,16.26) C1.2
  LYR4 w0.133: v1(14.1,42.4) 13.46,41.77 13.46,36.2 12.95,35.69 12.95,24 13.46,23.5 13.46,18.92 12.7,18.16 v1(12.7,16.26) 13.97,14.99 16.13,14.99 v1(18.8,12.32)
  BOTTOM w0.121: P4.1 7,42.53 8.26,41.27 12.19,41.27 12.45,41.53 12.45,41.85 C36.1 13.03,42.41 14.09,42.41 v1(14.1,42.4) 14.61,41.89 14.61,41.02 17.21,38.42 R159.1
USR0: length 34.9
  TOP w0.121: v1(14.8,44.77) 21.46,38.1 33.91,38.1 35.31,39.5 37.59,39.5 39.5,37.59 40.13,37.59 41.32,36.4 U5.V15 ; v1(13.02,44.77) Q1.2
  BOTTOM w0.121: v1(14.8,44.77) v1(13.02,44.77) R76.1
USR1: length 38.6
  TOP w0.121: U5.U15 40.92,35.61 40.92,36.42 40.01,37.34 39.37,37.34 37.47,39.24 35.56,39.24 34.16,37.85 20.95,37.85 14.29,44.51 v1(14.29,47.31) 14.29,47.75 14.1,47.94 13.21,47.94 13.02,47.75 Q1.5
  BOTTOM w0.121: R77.1 v1(14.29,47.31)
USR2: length 38.5
  TOP w0.121: v1(40.92,34.81) U5.T15 ; v1(9.53,44.77) Q2.2
  LYR3 w0.133: v1(9.53,44.77) 9.53,43.43 13.84,39.12 36.61,39.12 v1(40.92,34.81)
  BOTTOM w0.121: v1(9.53,44.77) R78.1
USR3: length 40.3
  TOP w0.121: Q2.5 9.53,47.69 9.78,47.94 10.54,47.94 10.79,47.69 v1(10.79,47.31) 11.3,46.8 11.3,44.58 11.94,43.94 14.35,43.94 20.7,37.59 34.42,37.59 35.81,38.99 37.34,38.99 39.24,37.09 39.87,37.09 40.52,36.44 U5.V16
  BOTTOM w0.121: R79.1 v1(10.79,47.31)
VDCDC1: length 5.5
  BOTTOM w0.381: v1(20.07,9.91) v1(20.7,9.91) 20.7,8.89 L1.2 20.07,8.89 v1(20.07,9.91) ; v1(20.07,9.91) 19.04,9.91 18.8,9.66 R6.1
VIO: length 26.9
  TOP w0.121: U2.18 22.66,11.67 22.16,11.18 v1(22.1,11.18) ; U16.5 32.4,8.12 32.14,8.38 v1(30.23,8.38) ; v1(12.7,14.48) 11.81,14.48 10.92,15.37 R7.2
  LYR3 w0.133: v1(22.1,11.18) 22.99,11.18 23.75,10.41 28.19,10.41 v1(30.23,8.38)
  LYR4 w0.133: v1(22.1,11.18) 21.62,11.66 18.57,11.66 15.75,14.48 v1(12.7,14.48)
VLDO1: length 10.6
  TOP w0.203: U2.3 18.42,16.64
  TOP w0.381: 18.42,16.64 17.65,15.88 R5.1 16.7,15.43 16.38,15.11 12.19,15.11 11.94,15.37 R7.1 R8.1
VREFP_ADC: length 7.7
  TOP w0.121: 45.72,22.81 45.72,21.84 45.59,21.72
  TOP w0.254: 45.72,22.81 U5.B9
  TOP w0.305: 45.29,21.42 45.59,21.72
  TOP w0.381: C32.1 C31.1 C33.1 44.1,18.32 R27.2 44.1,19.54 45.21,20.65 45.21,21.34 45.29,21.42
VRTC: length 42.3
  TOP w0.254: v1(48.12,24.41) U5.D7
  TOP w0.381: R5.2 15.68,16.38 15.94,16.64 16.45,16.64 16.7,16.89 C16.1 17.59,17.46 v1(18.03,17.91)
  LYR3 w0.381: v1(18.8,21.08) 19.16,20.72 25.55,20.72 27.3,22.48 33.91,22.48 35.56,20.83 38.61,20.83 39.77,19.66 40.75,19.66 41.02,19.94 46.35,19.94 47.31,20.89 v1(47.31,20.95)
  LYR4 w0.381: v1(18.8,21.08) 18.03,20.32 v1(18.03,17.91)
  BOTTOM w0.178: R26.1 49.82,19.18 49.69,19.3 49.69,20.67 49.4,20.95 v1(49.21,20.95)
  BOTTOM w0.381: C105.1 v1(47.31,20.95)
WAKEUP: length 60.9
  TOP w0.121: U2.13 20.66,11.22 v1(20.7,11.18) ; U5.C5 v1(49.72,23.61)
  LYR3 w0.133: v1(57.02,11.68) 56.52,11.18 56.52,10.03 55.88,9.4 42.16,9.4 40.64,7.87 28.96,7.87 27.43,9.4 24.13,9.4 22.86,10.67 21.21,10.67 v1(20.7,11.18)
  LYR4 w0.133: v1(49.72,23.61) 49.28,23.16 49.28,22.55 51.56,20.26 51.56,17.53 51.94,17.14 52.7,17.14 54.86,14.99 54.86,13.84 v1(57.02,11.68)
  BOTTOM w0.121: v1(49.72,23.61) 50.12,23.21 50.12,22.54 50.16,22.5 R26.2
WP: length 28.1
  BOTTOM w0.121: TP4.1 11.81,19.05 15.11,22.35 20.07,22.35 21.23,23.51 23.54,23.51 24.64,22.42 R156.2 25.43,22.42 25.55,22.54 25.55,23.26 25.81,23.51 27.98,23.51 28.23,23.26 U7.5
XDMA_EVENT_INTR0: length 16.4
  BOTTOM w0.121: P2.17 34.23,17.46 34.92,16.76 34.92,15.37 36,14.29 40.48,14.29 42.38,12.39 42.38,11.02 42.28,10.92 R18.2 41.91,10.79 42.25,10.45 U6.1
YEL_C: length 3.2
  TOP w0.121: v1(4.32,27.94) 4.32,27.03 P5.11
  BOTTOM w0.121: R130.2 v1(4.32,27.94)
YELA: length 27.8
  TOP w0.121: v1(23.69,27.69) 23.83,27.83 U14.2
  LYR3 w0.133: v1(23.69,27.69) 23.18,28.19 22.61,28.19 21.72,27.3 21.08,27.3 17.78,24 14.61,24 12.06,26.54 7.11,26.54 4.88,24.31 P5.12
  BOTTOM w0.121: R135.1 5.21,25.1 4.88,24.77 P5.12
ZQ: length 2.5
  TOP w0.121: v1(66.3,22.36) U12.L8
  BOTTOM w0.121: v1(66.3,22.36) 66.7,21.96 R99.2
N21667305: length 2.1
  TOP w0.121: v1(67.44,45.21) 67.25,45.03 U11.49
  BOTTOM w0.121: R149.1 67.44,45.09 v1(67.44,45.21)
N21757673: length 4.1
  TOP w0.121: v1(9.53,18.41) C19.1 R10.1
  BOTTOM w0.121: U4.4 v1(9.53,18.41) C19.1
N21769115: length 6.7
  TOP w0.121: R75.2 73.66,44.13 S2.3 S2.1
N22155575: length 23.5
  TOP w0.121: v1(40.92,33.21) U5.P15
  LYR5_PWR w0.121: v1(40.01,38.99) 40.48,38.52 40.48,37.93 40.72,37.68 41.07,37.68 41.32,37.43 41.32,33.61 v1(40.92,33.21)
  BOTTOM w0.121: R159.2 24.7,38.42 25.27,38.99 v1(40.01,38.99)
N22248684: length 1.7
  TOP w0.121: v1(40.96,43.18) 41.15,42.99 Y4.3
  BOTTOM w0.121: R167.1 v1(40.96,43.18)
N22248838: length 1.9
  BOTTOM w0.121: U6.5 48.13,12.41 48.26,12.28 R21.1
N22287501: length 12.7
  TOP w0.121: U3.4 40.97,47.55 40.64,47.88 37.08,47.88 v1(36.7,48.26)
  BOTTOM w0.121: v1(36.7,48.26) 36.2,48.77 30.99,48.77 30.48,48.26 R162.1
N22287555: length 15.1
  TOP w0.121: v1(41.72,34.01) U5.R14 ; v1(41.15,38.99) 41.27,38.86 41.78,38.86 42.42,39.5 42.42,43.56 42.04,43.94 40.44,43.94 40.32,44.06 U3.2
  LYR5_PWR w0.121: v1(41.72,34.01) 42.12,34.41 42.12,35.1 41.66,35.56 41.66,37.81 41.7,37.81 41.95,38.05 41.95,38.53 41.7,38.77 41.37,38.77 v1(41.15,38.99)
N22420400: length 9.8
  TOP w0.203: U2.4 18.91,16.24 v1(18.8,16.13) 19.09,15.84 U2.5
  LYR3 w0.381: TP5.1 14.73,12.95 17.91,16.13 v1(18.8,16.13)
N22420444: length 10.3
  TOP w0.203: U2.6 v1(18.29,15.44)
  LYR3 w0.203: TP6.1 16,9.4 16,13.15 v1(18.29,15.44)
N22420447: length 4.1
  TOP w0.203: U2.11 19.28,13.44 18.29,12.45 18.29,11.68 TP7.1
N22488252: length 25.3
  TOP w0.121: TP9.1 25.02,23.62 28.19,23.62 30.99,20.83 30.99,20.07 32.38,18.67 33.53,18.67 34.16,19.3 34.16,23.55 35.39,24.78 36.05,24.78 36.58,24.26 37.21,24.26 38.17,25.21 39.32,25.21 U5.E17

## Copper pours and planes (outline as drawn)
DGND on TOP (solid shape): 81.25,12.7 77.44,12.7 77.44,16.51 81.25,16.51
DGND on TOP: 38.73,43.43 38.99,43.69 41.66,43.69 41.91,43.43 41.91,39.62 41.66,39.37 38.99,39.37 38.73,39.62
DGND on BOTTOM: 19.56,16.07 19.56,15.3 19.81,15.05 20.7,15.05 20.95,14.8 20.95,13.14 20.7,12.89 19.94,12.89 19.68,12.64 19.68,12.26 19.94,12 22.61,12 22.86,12.26 22.86,13.53 23.11,13.78 24.13,13.78 24.38,14.03 24.38,14.67 25.15,14.67 25.15,14.41 25.4,14.16 26.04,14.16 26.29,14.41 26.29,16.07 26.04,16.32 25.4,16.32 25.15,16.07 25.15,15.81 24.38,15.81 24.38,16.07 24.13,16.32 23.5,16.32 23.24,16.07 23.24,15.81 22.48,15.81 22.48,16.07 22.23,16.32 21.59,16.32 21.34,16.07 21.34,15.81 20.57,15.81 20.57,16.07 20.32,16.32 19.81,16.32
DGND on BOTTOM: 41.27,30.48 41.4,30.61 41.4,30.99 41.91,30.99 41.91,30.61 42.16,30.35 42.16,29.72 41.91,29.46 41.91,29.08 41.27,29.08
DGND on LYR2_GND: outline of 81 points within 1.91,1.27 84.14,53.34
GND_EARTH on TOP: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_EARTH on BOTTOM: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_EARTH on LYR5_PWR: 6.35,0.64 2.31,2.31 0.64,6.35 0.64,48.26 2.31,52.3 6.35,53.98 73.66,53.98 82.19,50.44 85.72,41.91 85.72,12.7 82.19,4.17 73.66,0.64 ; 1 cut-out
GND_OSC0 on BOTTOM: 42.67,38.86 41.91,38.86 41.66,39.12 41.66,42.93 41.91,43.18 48.51,43.18 48.77,42.93 48.77,39.12 48.51,38.86 47.75,38.86 47.75,39.5 47.62,39.62 42.67,39.62
GND_OSC1 on TOP: 48.51,18.03 48.26,17.78 48.26,10.16 48.51,9.91 53.72,9.91 53.98,10.16 53.98,17.78 53.72,18.03 ; 1 cut-out
VDD_1V8 on LYR3: 41.91,34.54 42.16,34.29 42.16,33.02 41.91,32.77 41.27,32.77 40.77,32.26 33.02,32.26 32.77,32.51 32.77,34.29 33.02,34.54
VDD_1V8 on LYR4: 45.72,25.15 45.47,24.89 41.66,24.89 41.4,25.15 41.4,28.45 41.15,28.7 40.01,28.7 39.75,28.96 39.75,34.29 40.01,34.54 42.55,34.54 42.8,34.8 42.8,36.32 43.05,36.58 54.86,36.58 55.12,36.32 55.12,35.31 54.86,35.05 45.97,35.05 45.72,34.8 45.72,29.72 45.34,29.34 45.34,29.08 45.72,28.7
VDD_1V8 on LYR5_PWR: 44.7,13.97 44.7,25.27 44.83,25.4 46.74,25.4 46.86,25.27 46.86,20.45 47.24,20.07 48.9,20.07 49.15,19.81 49.15,13.97 48.9,13.72 44.96,13.72
VDD_1V8 on LYR5_PWR: 32.51,34.29 32.26,34.04 32.26,28.19 29.59,25.53 29.59,25.27 27.69,23.37 27.69,21.84 26.42,20.57 26.42,17.53 26.67,17.27 30.73,17.27 30.99,17.53 30.99,20.57 33.78,23.37 33.78,34.04 33.53,34.29
VDD_3V3A on BOTTOM: 42.29,36.45 42.29,35.81 41.91,35.43 41.91,33.27 42.16,33.02 43.31,33.02 43.43,33.15 43.43,33.27 43.05,33.66 43.05,35.56 42.76,35.85 42.76,36.45
VDD_3V3A on BOTTOM: 48.13,33.02 50.04,33.02 50.29,33.27 50.29,35.18 50.76,35.64 50.76,36.45 50.29,36.45 50.29,35.81 49.91,35.43 49.91,33.91 49.53,33.91 49.53,35.43 49.15,35.81 49.15,36.45 48.69,36.45 48.69,35.86 48.26,35.43 48.26,33.66 48.01,33.4 48.01,33.15
VDD_3V3A on BOTTOM: 39.88,29.72 40.39,29.72 40.77,29.34 40.77,29.08 41.02,28.83 41.66,28.83 41.91,28.57 41.91,27.56 41.4,27.56 41.4,27.94 41.02,28.32 40.51,28.32 40.26,28.57 38.61,28.57 38.61,29.08 39.24,29.08
VDD_3V3A on LYR5_PWR: 21.59,11.68 21.34,11.94 21.34,23.37 21.59,23.62 27.18,23.62 27.43,23.37 27.43,22.1 26.16,20.83 26.16,17.4 26.54,17.02 30.86,17.02 31.24,17.4 31.24,20.45 34.04,23.24 34.04,34.04 33.27,34.8 32.51,34.8 32.26,35.05 32.26,37.08 37.85,42.67 37.85,45.97 38.1,46.23 41.27,46.23 41.53,45.97 41.53,44.96 41.78,44.7 49.53,44.7 52.2,47.37 73.15,47.37 73.41,47.12 73.41,45.34 73.15,45.09 68.96,45.09 68.07,45.97 59.94,45.97 59.05,45.09 54.23,45.09 53.85,44.7 53.85,34.8 53.59,34.54 50.55,34.54 50.16,34.16 50.16,31.5 49.15,30.48 49.15,29.46 48.9,29.21 42.55,29.21 42.04,28.7 42.04,28.32 41.91,28.19 40.64,28.19 40.39,27.94 40.39,27.3 40.64,27.05 41.91,27.05 42.16,26.8 42.16,26.54 41.15,25.53 41.15,24.89 41.4,24.64 42.8,24.64 43.05,24.89 43.05,25.27 43.18,25.4 44.32,25.4 44.45,25.27 44.45,13.84 44.83,13.46 48.9,13.46 49.15,13.21 49.15,5.59 48.9,5.33 39.88,5.33 39.62,5.59 39.62,11.3 39.24,11.68
VDD_3V3B on BOTTOM: 25.08,35.24 24.13,35.24 24.13,36.51 26.04,36.51 26.35,36.2 26.35,33.53 25.75,33.53 25.08,34.2
VDD_3V3B on LYR5_PWR: outline of 88 points within 1.91,1.27 84.14,53.34
VDD_5V on TOP: 19.26,13.74 19.26,13.94 10.92,13.94 10.41,13.43 10.41,9.65 10.92,9.14 12.45,9.14 12.95,9.65 12.95,11.68 13.46,12.19 17.56,12.19 19.11,13.74
VDD_CORE on TOP: 27.3,14.1 27.3,12.95 27.56,12.7 29.21,12.7 29.46,12.95 29.46,13.84 31.37,13.84 31.5,13.97 31.5,14.73 31.38,14.85 26.6,14.85 26.49,14.74 25.91,14.74 25.91,14.54 26.86,14.54
VDD_CORE on LYR3: 49.15,25.53 45.97,25.53 45.72,25.78 45.72,26.92 45.34,27.3 42.42,27.3 42.16,27.05 42.16,24.13 41.91,23.88 32.77,23.88 32,24.64 32,25.65 32.51,26.16 33.27,26.16 33.53,26.42 33.53,27.43 33.78,27.69 40.26,27.69 40.26,29.21 41.15,29.21 41.15,30.23 40.51,30.23 40.01,30.73 40.01,31.11 40.39,31.5 41.4,31.5 41.78,31.88 43.43,31.88 45.21,33.66 49.15,33.66 49.4,33.4 49.4,25.78
VDD_MPU on TOP: 25.21,11.75 25.02,11.75 25.02,12.38 25.72,12.38 26.54,11.56 27.94,11.56 27.94,11.18 27.3,10.54 27.3,8.64 27.05,8.38 26.29,8.38 25.91,8.76 25.91,11.05
VDD_MPU on LYR3: 45.47,21.08 45.47,26.8 45.21,27.05 42.55,27.05 42.42,26.92 42.42,23.62 41.27,22.48 35.94,22.48 35.81,22.35 35.81,21.34 35.94,21.21 40.13,21.21 40.51,20.83 45.21,20.83
VDD_PHYA on LYR5_PWR: 10.54,23.5 9.27,22.23 2.54,22.23 1.91,22.86 1.91,28.26 2.54,28.89 2.54,30.8 1.91,31.43 1.91,36.83 2.54,37.47 9.27,37.47 10.54,36.2 12.06,36.2 12.95,37.08 23.11,37.08 23.37,36.83 23.37,27.43 23.11,27.18 21.34,27.18 17.65,23.5
VDD_PLL on BOTTOM: 38.48,28.07 39.12,28.07 39.24,28.19 40.77,28.19 41.02,27.94 41.02,27.3 40.77,27.05 39.62,27.05 39.12,27.56 38.48,27.56
VDD_PLL on BOTTOM: 48.51,20.07 48.51,22.73 48.77,22.99 48.77,25.15 48.51,25.4 47.75,25.4 47.5,25.15 47.5,21.21 48.01,20.7 48.01,20.07
VDD_PLL on BOTTOM: 43.56,33.53 44.07,33.02 44.2,33.02 45.09,33.91 45.09,34.16 44.7,34.54 44.7,35.43 43.97,36.16 43.97,36.45 43.47,36.45 43.47,35.78 43.56,35.69
VDD_PLL on LYR4: 39.75,28.19 40.89,28.19 41.15,27.94 41.15,27.3 40.89,27.05 38.61,27.05 38.35,27.3 38.35,31.62 38.48,31.75 39.37,31.75 39.5,31.62 39.5,28.45
VDD_PLL on LYR5_PWR: 40.64,27.43 40.77,27.3 42.42,27.3 42.67,27.56 46.35,27.56 47.12,26.8 47.12,25.15 47.24,25.02 48.9,25.02 49.15,25.27 49.15,28.7 48.9,28.96 42.67,28.96 42.29,28.57 42.29,28.19 42.04,27.94 40.77,27.94 40.64,27.81
VDDS on BOTTOM: 47.88,35.49 47.56,35.81 47.56,36.45 47.08,36.45 47.08,35.81 46.74,35.47 46.74,33.91 46.35,33.53 46.35,33.15 46.48,33.02 47.24,33.02 47.88,33.66
VDDS on BOTTOM: 38.61,22.61 39.37,22.61 39.62,22.86 39.62,23.62 39.88,23.88 41.27,23.88 41.53,24.13 41.53,24.51 41.66,24.64 41.91,24.64 42.04,24.77 42.04,25.4 41.91,25.53 41.27,25.53 40.51,26.29 39.62,26.29 39.37,26.04 39.37,25.27 39.12,25.02 38.48,25.02 38.48,22.73
VDDS on LYR4: 46.23,25.65 45.97,25.91 45.97,28.83 45.72,29.08 45.72,29.34 45.97,29.59 45.97,34.54 46.23,34.8 49.15,34.8 49.4,34.54 49.4,24.26 49.15,24 48.01,24 47.75,24.26 47.75,25.4 47.5,25.65
VDDS on LYR5_PWR: 42.67,24.89 41.53,24.89 41.4,25.02 41.4,25.4 42.42,26.42 42.42,26.92 42.8,27.3 46.23,27.3 46.86,26.67 46.86,25.78 46.74,25.65 43.05,25.65 42.8,25.4 42.8,25.02
VDDS_DDR on LYR3: 60.33,6.1 60.33,2.86 60.01,2.54 18.67,2.54 18.41,2.79 18.41,8.38 18.67,8.64 27.18,8.64 29.72,6.1 45.85,6.1 46.1,6.35 60.07,6.35
VDDS_DDR on LYR5_PWR: 49.4,30.35 49.4,25.27 49.66,25.02 50.04,25.02 50.29,24.77 50.29,20.7 49.4,19.81 49.4,5.84 49.85,5.4 60.33,5.4 60.64,5.71 60.64,15.88 60.96,16.19 70.17,16.19 70.48,16.51 70.48,33.97 70.17,34.29 50.67,34.29 50.42,34.04 50.42,31.37
HDMI_1V8 on LYR5_PWR: 54.1,34.8 54.36,34.54 70.1,34.54 70.36,34.8 70.36,44.58 70.1,44.83 68.83,44.83 67.94,45.72 60.07,45.72 59.18,44.83 54.36,44.83 54.1,44.58
P_L1 on TOP: 23.18,11.06 23.18,10.74 22.61,10.16 22.23,10.16 22.1,10.03 22.1,9.78 22.35,9.53 23.5,9.53 23.75,9.78 23.75,11.11 23.5,11.37
P_L2 on TOP: 24.64,9.53 24.38,9.78 24.38,10.67 24.51,10.79 24.51,11.46 24.64,11.59 24.73,11.59 25.53,10.79 25.53,9.78 25.27,9.53
P_L3 on TOP: 26.44,15.34 25.91,15.34 25.91,15.56 26.73,15.56 27.3,16.13 27.3,17.53 27.56,17.78 29.34,17.78 29.46,17.65 29.46,17.14 29.34,17.02 28.19,17.02 28.07,16.89 28.07,15.75 27.56,15.24 26.54,15.24
RXP on BOTTOM (solid shape): 14.62,34.29 13.84,33.57 13.16,34.25 13.15,34.29 13.16,34.33 13.84,35.01
SYS_5V on LYR5_PWR: 83.5,20.64 75.25,20.64 73.98,21.91 73.98,24.13 73.66,24.45 71.12,24.45 70.8,24.13 70.8,16.19 70.48,15.88 61.28,15.88 60.96,15.56 60.96,5.4 60.64,5.08 26.35,5.08 26.04,4.76 26.04,1.59 26.35,1.27 75.88,1.27 77.15,2.54 77.15,8.26 76.52,8.89 74.61,8.89 73.98,9.53 73.98,11.11 74.61,11.75 83.5,11.75 84.14,12.38 84.14,20
VDCDC1 on TOP: 20.07,10.73 22.23,10.73 22.96,11.47 22.96,12.19 23.16,12.19 23.16,11.29 22.99,11.11 22.99,10.79 22.48,10.29 21.84,10.29 21.59,10.03 21.59,9.78 21.34,9.53 20.07,9.53 19.81,9.78 19.81,10.48
VRTC on LYR3: 48.51,24.64 47.75,24.64 47.5,24.38 47.5,21.59 47.12,21.21 47.12,20.83 47.24,20.7 49.28,20.7 49.4,20.83 49.4,21.21 48.77,21.84 48.77,24.38
VRTC on LYR5_PWR: 47.37,20.32 49.53,20.32 50.04,20.83 50.04,24.64 49.91,24.77 47.24,24.77 47.12,24.64 47.12,20.57

Small or netless copper shapes (teardrops, artwork): 540 on TOP, 376 on BOTTOM, 188 on LYR3, 170 on LYR4, 10 on LYR5_PWR, 1 on LYR2_GND

## Text on the board
BOTTOM: PCB RevB6 | LAYER 6 | SOLDER
Board Geometry/Soldermask Bottom: SMS
Ref Des/Silkscreen Bottom: S/N | BSLK
TOP: LAYER 1 | COMPONENT
Board Geometry/Soldermask Top: SMC
Ref Des/Silkscreen Top: USER LEDS | 0 | 1 | 2 | 3 | RESET | POWER | PWR | USB | AM335x | USB Host | HDMI | 10/100 Ethernet | microSD Card | TSLK
LYR2_GND: LAYER 2 | GROUND
LYR3: LAYER 3 | SIGNAL
LYR4: LAYER 4 | SIGNAL
LYR5_PWR: LAYER 5 | POWER
DISPLAY_TOP: SPC
DISPLAY_BOTTOM: SPS
DIMENSION: (OZ) | LAYER 1 - PRIMARY SIDE - SIGNAL | LAYER 2 - GROUND PLANE | LAYER 3 - SIGNAL | LAYER 4 - SIGNAL | LAYER 5 - SPLIT POWER PLANE | LAYER 6 - SECONDARY SIDE - SIGNAL | LAYER# | COPPER WEIGHT | HALF+PLATING | IMPEDANCE CONTROL | +/- 10% | 50ohm SINGLE ENDED | TRACE WIDTH | TRACE WIDTH / SPACE | 90ohm DIFFERENTIAL | 100ohm DIFFERENTIAL | 9. ALL VIAS TO HAVE SOLDERMASK. | FINISHED AS SMOOTH WALL BY VEDOR. | PROCESS NOTES: | 2. APPLY LPI SOLDERMASK OVER BARE COPPER (SMOBC), | COLOR: BLACK. SOLDERMASK SHALL CONFIRM TO IPC-SM-840. | CLASS H. CURRENT REV. | 3. SOLDERMASK ARTWORK HAS ZERO (0) OVERSIZED PADS. | FABRICATION VENDOR IS ALLOWED TO ADJUST THE COMPONENT | SOLDERMASK PADS TO MEET THEIR TOOLING REQUIREMENTS. | 4. APPLY LPI SILKSCREEN OR EQUIVALENT PER THE ARTWORK. | COLOR: WHITE. | 1. PLATE ALL EXPOSED AREAS WITH ELECTROLESS | IMMERSION GOLD, NICKEL 150 MICROINCHES THK MIN | GOLD 5-15 MICROINCHES THK MIN. | SUPPLIED IPC-D-356 NETLIST. | FAB NOTES: | 1. ALL DIMENSIONS ARE IN INCHES, UNLESS | OTHERWISE NOTED. | 2. THE PWB SHALL BE FABRICATED TO IPC-6012, | CLASS 2 AND WORKMANSHIP SHALL CONFORM TO | IPC-A-600, CLASS 2. CURRENT REVISIONS. | 3. BOARD MATERIAL SHALL BE 180 Tg/350 Td ISOLA FR-370HR | OR EQUIVALENT, RoHS COMPLIANT AND LEAD FREE | ASSEMBLY CAPABLE.  BOARD MATERIAL SHALL | MEET OR EXCEED IPC-4101B. COLOR: NATURAL. | 4. BOARD MATERIAL & CONSTRUCTION TO BE U.L. | APPROVED AND MARKED ON THE FINISHED BOARD. | 5. MINIMUM COPPER WALL THICKNESS OF PLATED-THRU | HOLES TO BE .001 INCH, WITH A MINIMUM | ANNULAR RING OF .002 INCH. | 6. OVERALL BOARD THICKNESS TO BE .062 +/- 10% | AND APPLIES AFTER ALL LAMINATION AND PLATING | PROCESSES, MEASURED FROM COPPER TO COPPER. | 7. MAX. WARP & TWIST TO BE .0075 INCHES PER INCH. | 8. BOARD MUST BE ELECTRICALLY TESTED USING | 1 | 5.25 | 4.75 | 4.5/6.5 | 5.0/7.0 | 3.75/7.25 | 4.00/8.00 | R.250 2X | LAYER STACK-UP - ALL DIMENSIONS IN INCHES
USER_PART_NUM_TOP: TSLKC
USER_PART_NUM_BOTTOM: BSLKC
User.12: DATE | DESIGN ENGR | PROJECT ENGR | ENGR MGR | NEXT ASSEMBLY | APPROVED | CHECKED | DRAFTING | ENGR | NONE | 1 OF 1
User.13: C100 | C73 | C97 | C98 | C99 | C25 | C48 | C46 | C58 | C41 | C66 | C65 | C60 | C70 | C26 | C87 | C45 | C79 | C54 | C44 | C82 | C83 | R49 | C84 | C69 | R158 | C71 | C86 | C85 | C67 | C38 | C78 | C52 | C53 | C51 | R116 | R131 | R140 | R134 | R145 | R113 | R138 | R115 | R112 | R114 | R117 | C134 | R150 | R154 | R155 | R153 | C154 | R151 | R152 | C68 | C43 | C50 | C81 | C56 | C42 | C47 | R17 | C49 | C72 | C88 | C106 | C94 | C63 | C80 | FB1 | C40 | C39 | D2 | D3 | D4 | D5 | USER LEDS | 0 | 1 | 2 | 3 | D1 | RESET | C19 | R10 | R72 | R73 | R74 | R71 | POWER | R9 | R7 | U10 | C1 | TP5 | TP6 | C16 | C3 | R5 | TP7 | TP8 | TP9 | C9 | C12 | P | R119 | R118 | A | R139 | R133 | R128 | R127 | R126 | R125 | R124 | R28 | 14 | 18 | U3 | Y4 | R27 | TP3 | V | TP1 | C96 | 16 | TP2 | 64 | 17 | 32 | 49 | 33 | R157 | R95 | C61 | R166 | D8 | 46 | 45 | U9 | 19 | R147 | R146 | C117 | C119 | R96 | R99 | C120 | C121 | C116 | C118 | FB7 | C151 | C114 | C115 | C122 | FB8 | R98 | C123 | R100 | C124 | R97 | C109 | C110 | C112 | C113 | C107 | C108 | C111 | R22 | C28 | U15 | FB2 | U6 | FB3 | C64 | C77 | R14 | C24 | C30 | L3 | U7 | C135 | C136 | R103 | C14 | C8 | L2 | R108 | R156 | R159 | C126 | C133 | C132 | C131 | C13 | FB4 | C7 | L1 | R144 | R129 | R123 | R122 | R121 | R120 | U4 | C137 | C140 | C138 | C139 | C141 | R137 | R11 | C17 | 5 | R135 | C2 | R12 | R132 | R130 | C | E | G | J | L | N | R | 7 | 9 | PWR | TP4 | R8 | Q2 | Q1 | C18 | R3 | R4 | C11 | C37 | C55 | U16 | C29 | R50 | R24 | R23 | R25 | C32 | C165 | C31 | C57 | R29 | C33 | C27 | R81 | R80 | R84 | C93 | R45 | R48 | R82 | R46 | R47 | R165 | R83 | C168 | C166 | R85 | C167 | C157 | R86 | R87 | R88 | R89 | R90 | R91 | C169 | C156 | C160 | C163 | R92 | R93 | R94 | R75 | C173 | C153 | R52 | C35 | C171 | R53 | C76 | C149 | R148 | R149 | C150 | C148 | C147 | C146 | R70 | R69 | R68 | R67 | C145 | C144 | R66 | R65 | R64 | R63 | C172 | C155 | FB5 | C75 | R62 | C95 | C103 | R61 | R101 | R60 | C170 | C102 | R105 | R58 | C162 | R30 | R102 | C101 | R57 | C161 | C22 | R110 | R54 | R59 | R106 | C74 | C21 | R26 | R109 | R55 | C164 | C104 | R164 | R21 | R56 | C92 | R163 | C105 | C89 | C91 | C90 | C59 | R20 | R19 | R167 | R18 | C158 | R51 | C159 | 20 | R160 | C62 | R161 | C125 | C130 | C129 | R162 | R111 | R104 | C128 | C152 | C127 | R107 | C143 | C15 | R142 | R1 | R141 | R143 | R6 | C4 | C10 | C142 | R77 | C36 | R76 | R79 | R78 | C20 | R136 | DATE | DESIGN ENGR | PROJECT ENGR | ENGR MGR | NEXT ASSEMBLY | APPROVED | CHECKED | DRAFTING | ENGR | 1 OF 1 | USB | S1 | P1 | P5 | U13 | U2 | U14 | Y3 | U5 | J1 | Y1 | AM335x | C34 | U11 | U12 | RT1 | D7 | D6 | S2 | P3 | P8 | P9 | USB Host | HDMI | P6 | P10 | U8 | S/N | Y2 | P4 | S3 | 10/100 Ethernet | microSD Card | P2 | ASSEMBLY SOLDER SIDE
User.14: NONE
User.27: 6.0 | 8.0 | 12.0 | 30.0 | 40.0 | 63.0 | 125.0 | 128.0 | 50.0x15.0 | 95.0x40.0 | 120.0x40.0 | 140.0x40.0 | DRILL CHART: TOP to BOTTOM | +3.0/-3.0 | +5.0/-5.0 | PLATED | NON-PLATED | 27 | 797 | 30 | 97 | 26 | 2 | 4 | 1 | FIGURE | SIZE | ALL UNITS ARE IN MILS | TOLERANCE | QTY
